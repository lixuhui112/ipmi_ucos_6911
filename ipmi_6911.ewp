# IAR project ipmi_6911.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3Sx9xx TexasInstruments LM3Sx9xx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_LM3S6911; BOARD_6911_FAN
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; app; ucos\src; ucos\ports; third_party\uip-1.0\uip; third_party\uip-1.0\apps; third_party\uip-1.0\apps\httpd
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm; PART_LM3S6911; BOARD_6911_FAN
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ipmi_6911.bin
  ILINK.IlinkOutputFile: ipmi_6911.out
  ILINK.IlinkIcfFile: ipmi_6911.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group App
    app/: lib_common.c lib_eth.c lib_i2c.c lib_io.c lib_spi.c lib_uart.c main.c startup_ewarm_6911.c
  group ipmi_lib
    ipmi_lib/: ipmi_app.c ipmi_bridge.c ipmi_channel.c ipmi_chassis.c ipmi_common.c ipmi_err.c ipmi_eth.c ipmi_firmware.c ipmi_icmb.c ipmi_ipmb.c ipmi_main.c ipmi_message.c ipmi_picmg.c ipmi_pmb.c ipmi_pow.c ipmi_sdr.c ipmi_sdr_mc_locator.c ipmi_se.c ipmi_sel.c ipmi_ssif.c ipmi_storage.c ipmi_temp.c ipmi_timer.c ipmi_transport.c sensor_adt7470.c sensor_at24xx.c sensor_ina230.c sensor_max6635.c sensor_uct9081.c
  group LM3S_Library
    driverlib/ewarm/Exe/: driverlib.a
  group third_party
    third_party/: uartstdio.c ustdlib.c
    third_party/uip-1.0/uip/: uip.c uip_arp.c uip_timer.c
  group ucOS
    ucos/ports/: os_cpu_a.asm os_cpu_c.c
    ucos/src/: ucos_ii.c
